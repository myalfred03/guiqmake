Commit message: First attempt to add gzserver

File: build-LabGUI-Desktop_Qt_5_9_1_GCC_64bit-Debug/modelos/robot2dof.urdf (robot description, URDF)
Before this commit: robot origins, 4 links, 3 joints
Links:
- link base_link: geometry collision box size=0.2 .3 0.1; visual box size=0.2 .3 .2
